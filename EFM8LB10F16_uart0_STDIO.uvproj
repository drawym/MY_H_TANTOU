# Keil uVision project EFM8LB10F16_uart0_STDIO.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8LB10F16E-QFN24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(72000000)
  output: EFM8LB10F16_uart0_STDIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: SILABS_STARTUP.A51
    ./src/: EFM8LB1_UART_STDIO.c InitDevice.c
