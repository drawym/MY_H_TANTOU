# IAR project EFM8LB1_DAC.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: EFM8LB12F64E EFM8LB12F64E
  ICC8051.CCDefines: __LB1__; DEBUG=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\device\shared\si8051base; ..\..\..\..\..\device\efm8lb1; ..\..\..\..\..\device\efm8lb1\inc; ..\inc
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Silicon Labs\lnk51ew_EFM8LB12F64E.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: __LB1__; NDEBUG=1
  ICC8051.CCOptLevel: 3
  group inc
    ../inc/: initdevice.h
  group src
    ../src/: efm8lb1_dac.c initdevice.c interrupts.c
